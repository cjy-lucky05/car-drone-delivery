# Keil uVision project wd_car.uvprojx, settings and files
target wd_car (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303RBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: wd_car +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User/Core
    ../Core/Src/: mainloop.c main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
    ../Core/Inc/: mainloop.h main.h
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group APP
    ../Core/Inc/APP/: uart_imu.h Sonar.h Servo.h PS2.h Motor.h Kinematics.h Indicate.h imu.h Config.h Communication.h Battery.h uart_servo.h
    ../Core/Src/APP/: uart_imu.c Sonar.c Servo.c PS2.c Motor.c Kinematics.c Indicate.c imu.c Communication.c Battery.c uart_servo.c
  group BSP
    ../Core/Src/BSP/: bsp_encoder.c bsp_motor.c bsp_servo.c ws2812.c
    ../Core/Inc/BSP/: bsp_encoder.h bsp_motor.h bsp_servo.h ws2812.h
software components: CMSIS:CORE 4.3.0
